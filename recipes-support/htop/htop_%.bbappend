do_install_append() {
	rm ${D}${datadir}/applications/htop.desktop
}
