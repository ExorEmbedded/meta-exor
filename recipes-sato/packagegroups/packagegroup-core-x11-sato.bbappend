#
# Copyright (C) 2007-2008 OpenedHand Ltd.
#

PACKAGES = "${PN} ${PN}-base ${PN}-apps "

RDEPENDS_${PN} = "\
    ${PN}-base \
    ${PN}-apps \
    "
