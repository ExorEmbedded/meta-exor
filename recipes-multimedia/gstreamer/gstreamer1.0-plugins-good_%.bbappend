PACKAGECONFIG_remove_usom03 = "x11"
