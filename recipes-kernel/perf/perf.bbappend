# Remove scripting 
PACKAGECONFIG = "tui libunwind"

