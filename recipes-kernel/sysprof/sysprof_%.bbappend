# Make sure gtk schemas get compiled
inherit gsettings
