RDEPENDS_${PN} = "\
    ${PROFILETOOLS} \
    ${BABELTRACE} \
    ${SYSTEMTAP} \
    ${VALGRIND} \
    "
