FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Set board hostname
hostname:usom04 = "exorUS04kit"
